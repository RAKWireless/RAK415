# Keil uVision project RAK415_UART_DEMO.uvproj, settings and files
target RAK415_UART_DEMO (ARM-ADS)
  device: M058LBN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: RAK415_UART_DEMO
  c flags: wLevel=2
  c include: ..\LibM051Series\StdDriver\inc;..\LibM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series;..\RAK_Include;..\RAK_Source
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\output\RAK410_UART_TEST.sct
  group Source
    ../RAK_Source/: USER_APP_Task.c RAK_WIFI_Driver.c BSP_Driver.c BSP_Init.c
  group CMSIS
    ../LibM051Series/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
    ../LibM051Series/StdDriver/src/: retarget.c
    ../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/iar/: startup_M051Series.s
  group API Library
    ../RAK_Driver/: rak_config_init.c rak_open_cmdMode.c rak_query_fwversion.c rak_query_macaddr.c rak_reset.c rak_read_userConfig.c rak_write_userConfig.c rak_read_restoreConfig.c rak_write_restoreConfig.c rak_restore.c rak_easy_txrxMode.c rak_copy_uConfig.c rak_query_constatus.c rak_query_ipconfig.c rak_query_tcpstatus.c rak_scan_ap.c rak_query_rssi.c rak_get_scan.c rak_easy_config.c rak_wps_config.c rak_send_data.c
